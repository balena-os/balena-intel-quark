do_compile_prepend() {
    export GO386=387
}
