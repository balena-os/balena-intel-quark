INTERNAL_DEVICE_KERNEL = "mmcblk0"

INTERNAL_DEVICE_BOOTLOADER_CONFIG = "grub.cfg_internal"

INTERNAL_DEVICE_BOOTLOADER_CONFIG_PATH = "/boot/grub/grub.conf"
