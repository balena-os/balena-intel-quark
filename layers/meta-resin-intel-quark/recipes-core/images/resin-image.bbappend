include resin-image.inc

RESIN_BOOT_PARTITION_FILES += " \
    grub.cfg_internal:/boot/grub/grub.conf \
    "
